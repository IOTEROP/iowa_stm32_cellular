# IAR project Prj_Iowa_L462.ewp, settings and files
configuration Iowa_Client_DiscoL462 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L462RE ST STM32L462RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; DISCO_L462; APPLICATION_CONFIG_FILE="plf_iowa_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_iowa_app_thread_config.h"
  ICCARM.CCIncludePath2: ..\..\Core\Inc; ..\..\STM32_Cellular\Config; ..\..\STM32_Cellular\Target; ..\..\..\..\Misc\Cmd\Inc; ..\..\..\..\Misc\RTOS\FreeRTOS\Inc; ..\..\..\..\..\Projects\Misc\Samples\Iowa_Client\Inc; ..\..\..\..\..\Drivers\BSP\X_STMOD_PLUS_MODEMS\TYPE1SC\AT_modem_type1sc\Inc; ..\..\..\..\..\Drivers\BSP\B-L462E-CELL1; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Data_Cache\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\PPPosif\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Ctrl\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip\prot; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif\ppp; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\Middlewares\Third_Party\Iowa\include; ..\..\..\..\..\Middlewares\Third_Party\Iowa\include\objects; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\coap; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\comm; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\core; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\data; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\logger; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\lwm2m; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\misc; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\objects; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\oscore; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\security; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\Drivers\BSP\Components\ssd1315
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Core\Inc; ..\..\STM32_Cellular\Config; ..\..\..\..\Misc\RTOS\FreeRTOS\Inc
  OBJCOPY.OOCOutputFile: Iowa_Client_DiscoL462.bin
  ILINK.IlinkOutputFile: Iowa_Client_DiscoL462.out
  ILINK.IlinkIcfFile: stm32l462xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Iowa_Client_DiscoL462_LwIP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; USE_SOCKETS_TYPE=USE_SOCKETS_LWIP; DISCO_L462; APPLICATION_CONFIG_FILE="plf_iowa_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_iowa_app_thread_config.h"; USE_LOW_POWER=0
  ICCARM.CCIncludePath2: ..\..\Core\Inc; ..\..\STM32_Cellular\Config; ..\..\STM32_Cellular\Target; ..\..\..\..\Misc\Cmd\Inc; ..\..\..\..\Misc\RTOS\FreeRTOS\Inc; D:\STM32_Devel\WK1\iowa_stm32_cellular\Projects\Misc\Samples\Iowa_Client\Inc; ..\..\..\..\..\Drivers\BSP\X_STMOD_PLUS_MODEMS\TYPE1SC\AT_modem_type1sc\Inc; ..\..\..\..\..\Drivers\BSP\B-L462E-CELL1; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Data_Cache\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\PPPosif\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Ctrl\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip\prot; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif\ppp; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\Middlewares\Third_Party\Iowa\include; ..\..\..\..\..\Middlewares\Third_Party\Iowa\include\objects; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\coap; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\comm; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\core; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\data; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\logger; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\lwm2m; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\misc; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\objects; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\oscore; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\security; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\Drivers\BSP\Components\ssd1315
configuration Iowa_Client_DiscoL462_Rel (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; SW_DEBUG_VERSION=0; DISCO_L462; APPLICATION_CONFIG_FILE="plf_iowa_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_iowa_app_thread_config.h"
configuration Iowa_Client_DiscoL462_LwIP_Rel (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; USE_SOCKETS_TYPE=USE_SOCKETS_LWIP; SW_DEBUG_VERSION=0; DISCO_L462; APPLICATION_CONFIG_FILE="plf_iowa_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_iowa_app_thread_config.h"; USE_LOW_POWER=0
  ICCARM.CCIncludePath2: ..\..\Core\Inc; ..\..\STM32_Cellular\Config; ..\..\STM32_Cellular\Target; ..\..\..\..\Misc\Cmd\Inc; ..\..\..\..\Misc\Ndlc\Core\Inc; ..\..\..\..\Misc\Ndlc\Interface\Inc; ..\..\..\..\Misc\RTOS\FreeRTOS\Inc; ..\..\..\..\..\Projects\Misc\Samples\Iowa_Client\Inc; ..\..\..\..\Misc\SPI\Inc; ..\..\..\..\..\Drivers\BSP\X_STMOD_PLUS_MODEMS\TYPE1SC\AT_modem_type1sc\Inc; ..\..\..\..\..\Drivers\BSP\B-L462E-CELL1; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Data_Cache\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\PPPosif\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Ctrl\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip\prot; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif\ppp; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\Middlewares\Third_Party\Iowa\include; ..\..\..\..\..\Middlewares\Third_Party\Iowa\include\objects; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\coap; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\comm; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\core; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\data; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\logger; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\lwm2m; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\misc; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\objects; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\oscore; ..\..\..\..\..\Middlewares\Third_Party\Iowa\src\security; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\Drivers\BSP\Components\ssd1315
configuration Jenkins_Config (ARM, debug)
  as the first configuration, except:
configuration Jenkins_CodeSonar (ARM, debug)
  as the first configuration, except:
  group Application/EWARM
    ./: startup_stm32l462xx.s
  group Application/User
    ../../Core/Src/: gpio.c i2c.c main.c quadspi.c rng.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c tim.c usart.c
  group Drivers/BSP/B-L462E-CELL1
    ../../../../../Drivers/BSP/B-L462E-CELL1/: stm32l462e_cell1.c stm32l462e_cell1_bus.c stm32l462e_cell1_eeprom.c stm32l462e_cell1_env_sensors.c stm32l462e_cell1_env_sensors_ex.c stm32l462e_cell1_lcd.c stm32l462e_cell1_motion_sensors.c stm32l462e_cell1_motion_sensors_ex.c
  group Drivers/BSP/Components/hts221
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
  group Drivers/BSP/Components/lps22hh
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
  group Drivers/BSP/Components/lsm303agr
    ../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
  group Drivers/BSP/Components/ssd1315
    ../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c
  group Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC
    ../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Src/: at_custom_modem_api.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c sysctrl_specific.c
    ../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Inc/: plf_modem_config.h
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/Cellular/Core/AT_Core
    ../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_signalling.c at_modem_socket.c at_parser.c at_util.c sysctrl.c
  group Middlewares/Cellular/Core/Cellular_Service
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Src/: cellular_service.c cellular_service_cmd.c cellular_service_config.c cellular_service_datacache.c cellular_service_int.c cellular_service_os.c cellular_service_power.c cellular_service_task.c cellular_service_utils.c
  group Middlewares/Cellular/Core/Data_Cache
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Src/: dc_common.c
  group Middlewares/Cellular/Core/Error
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Src/: error_handler.c
  group Middlewares/Cellular/Core/HW_Specific
    ../../STM32_Cellular/Target/: board_interrupts.c
  group Middlewares/Cellular/Core/Ipc
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/Cellular/Core/PPPosif
    ../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Src/: ppposif.c ppposif_client.c ppposif_ipc.c
  group Middlewares/Cellular/Core/Rtosal
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Src/: rtosal.c
  group Middlewares/Cellular/Core/Runtime_Library
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
  group Middlewares/Cellular/Core/Trace
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Src/: trace_interface.c
  group Middlewares/Cellular/Interface/Com
    ../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Src/: com_core.c com_icc.c com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c com_sockets_statistic.c com_utils.c
  group Middlewares/Cellular/Interface/Control
    ../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Src/: cellular_control_api.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/Iowa/coap
    ../../../../../Middlewares/Third_Party/Iowa/src/coap/: iowa_block.c iowa_coap.c iowa_coap_lorawan.c iowa_coap_sms.c iowa_coap_tcp.c iowa_coap_udp.c iowa_coap_utils.c iowa_message.c iowa_option.c iowa_peer.c iowa_prv_coap.h iowa_prv_coap_internals.h iowa_transaction.c
  group Middlewares/Third_Party/Iowa/comm
    ../../../../../Middlewares/Third_Party/Iowa/src/comm/: iowa_comm.c iowa_prv_comm.h
  group Middlewares/Third_Party/Iowa/core
    ../../../../../Middlewares/Third_Party/Iowa/src/core/: iowa_base.c iowa_buffer.c iowa_client.c iowa_comms.c iowa_context.c iowa_prv_core.h iowa_prv_core_check_config.h iowa_prv_core_internals.h iowa_prv_timer.h iowa_server.c iowa_timer.c
  group Middlewares/Third_Party/Iowa/data
    ../../../../../Middlewares/Third_Party/Iowa/src/data/: iowa_cbor.c iowa_data.c iowa_data_utils.c iowa_json.c iowa_prv_data.h iowa_prv_data_internals.h iowa_senml_cbor.c iowa_senml_json.c iowa_text_opaque.c iowa_tlv.c
  group Middlewares/Third_Party/Iowa/logger
    ../../../../../Middlewares/Third_Party/Iowa/src/logger/: iowa_logger.c iowa_prv_logger.h
  group Middlewares/Third_Party/Iowa/lwm2m
    ../../../../../Middlewares/Third_Party/Iowa/src/lwm2m/: iowa_acl.c iowa_attributes.c iowa_bootstrap.c iowa_core_link.c iowa_lwm2m.c iowa_lwm2m_utils.c iowa_management.c iowa_objects.c iowa_observe.c iowa_packet.c iowa_prv_lwm2m.h iowa_prv_lwm2m_internals.h iowa_registration.c iowa_send.c iowa_uri.c iowa_value.c
  group Middlewares/Third_Party/Iowa/misc
    ../../../../../Middlewares/Third_Party/Iowa/src/misc/: iowa_list.c iowa_prv_misc.h iowa_utils.c
  group Middlewares/Third_Party/Iowa/objects
    ../../../../../Middlewares/Third_Party/Iowa/src/objects/: iowa_object_accelerometer.c iowa_object_acl.c iowa_object_apn_connection_profile.c iowa_object_at_command.c iowa_object_bearer_selection.c iowa_object_cellular_connectivity.c iowa_object_connectivity_monitoring.c iowa_object_connectivity_stats.c iowa_object_device.c iowa_object_digital_output.c iowa_object_firmware.c iowa_object_gps.c iowa_object_gyrometer.c iowa_object_internals.c iowa_object_ipso.c iowa_object_light_control.c iowa_object_location.c iowa_object_magnetometer.c iowa_object_oscore.c iowa_object_security.c iowa_object_server.c iowa_object_software_component.c iowa_object_software_management.c iowa_prv_objects.h iowa_prv_objects_internals.h
  group Middlewares/Third_Party/Iowa/oscore
    ../../../../../Middlewares/Third_Party/Iowa/src/oscore/: iowa_cose.c iowa_oscore.c iowa_prv_oscore_internals.h
  group Middlewares/Third_Party/Iowa/security
    ../../../../../Middlewares/Third_Party/Iowa/src/security/: iowa_layer_mbedtls.c iowa_layer_tinydtls.c iowa_prv_security.h iowa_prv_security_internals.h iowa_security.c iowa_security_helper.c
  group Middlewares/Third_Party/LwIP/api
    ../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Third_Party/LwIP/core
    ../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/LwIP/core/ipv4
    ../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Third_Party/LwIP/netif/ppp
    ../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppos.c upap.c utils.c vj.c
  group Middlewares/Third_Party/LwIP/system/OS
    ../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Misc/Cmd
    ../../../../Misc/Cmd/Src/: cmd.c
  group Misc/FreeRTOS
    ../../../../Misc/RTOS/FreeRTOS/Src/: freertos.c
  group Misc/Samples/Iowa_Client
    ../../../../Misc/Samples/Iowa_Client/Src/: custom_object.c iowa_app_l462e_cell1.c iowa_client.c iowa_platform.c main_app.c
    ../../../../Misc/Samples/Iowa_Client/Inc/: custom_object.h iowa_app.h iowa_config.h plf_iowa_app_config.h plf_iowa_app_thread_config.h
  group plf_config
    ../../STM32_Cellular/Config/: plf_config.h plf_features.h plf_hw_config.h plf_ipc_config.h plf_power_config.h plf_sw_config.h plf_thread_config.h
