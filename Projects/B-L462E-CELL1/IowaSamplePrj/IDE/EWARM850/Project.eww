<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Prj_Iowa_L462.ewp</path>
  </project>
  <batchBuild />
</workspace>
